Commit message: inertia fixed

File: gym_pybullet_drones/assets/maze/map_21.urdf (robot description, URDF)
Before this commit: robot maze, 3 links, 2 joints
Links:
- link walls: mass None -> 1
