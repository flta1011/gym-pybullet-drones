Commit message: Ergänzung der sich am meisten unterscheidenden mazes

File: gym_pybullet_drones/assets/maze/maze_rs_8.urdf (robot description, URDF)
Before this commit: robot maze, 3 links, 2 joints
Links:
- link walls: geometry collision box size=0.05 0.05 1; collision box size=0.05 0.05 1
